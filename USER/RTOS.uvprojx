# Keil uVision project RTOS.uvprojx, settings and files
target RTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\USER;..\CORE;..\FW LIB;..\FW LIB\inc;..\FW LIB\inc\CMSIS;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\portable\RVDS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group USER
    ./: main.c
  group FW LIB
    ../FW LIB/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group CORE
    ../CORE/: system_msp432p401r.c startup_MSP432P4.s
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_1.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
